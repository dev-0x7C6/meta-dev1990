WALLPAPER_DIR ?= "${datadir}/wallpapers"