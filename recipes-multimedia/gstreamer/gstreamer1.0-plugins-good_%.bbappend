PACKAGECONFIG_append = " libv4l2 v4l2"