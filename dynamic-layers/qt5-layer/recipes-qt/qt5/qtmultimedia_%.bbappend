PACKAGECONFIG_append = " gstreamer"