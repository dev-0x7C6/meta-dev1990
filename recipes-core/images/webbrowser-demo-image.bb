DESCRIPTION = "Image contains led-frame and configuration"

inherit core-image

IMAGE_INSTALL += "qt-kiosk-browser-demo"
