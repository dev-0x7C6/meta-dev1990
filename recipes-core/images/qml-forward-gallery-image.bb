DESCRIPTION = "Image contains qbijin-tokei"

inherit core-image

IMAGE_INSTALL += " \
  tzdata \
  anime-wallpaper-selection-2021q2 \
  qml-forward-gallery \
  qml-forward-gallery-service \
"
