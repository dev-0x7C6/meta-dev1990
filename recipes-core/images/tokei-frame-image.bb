DESCRIPTION = "Image contains tokei-frame"

inherit core-image

IMAGE_INSTALL_append = " tokei-frame"
