FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://msr.cfg"
