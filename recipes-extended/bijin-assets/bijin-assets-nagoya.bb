
require bijin-assets.inc

SRC_URI[md5sum] = "d2e9e4d183f20a4bc4795579e1272848"
SRC_URI[sha256sum] = "b92354caf80771b10864e511a549597a04b41d8fc2747d1b2d97ebfcf6268c5d"
