
require bijin-assets.inc

SRC_URI[md5sum] = "79881c5a06fb509c8bdf9eef5340a9f1"
SRC_URI[sha256sum] = "32aec63dca0fde0a056a416c4b1f39753b50f927b5b79d00824c4d26595fcdfb"
