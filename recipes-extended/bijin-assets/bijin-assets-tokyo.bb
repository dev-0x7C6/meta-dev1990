
require bijin-assets.inc

SRC_URI[md5sum] = "9103ac9c593ae740d9bdad6f121e6bd1"
SRC_URI[sha256sum] = "2c5c339bf4e689eef349c9d7eac3b437770ee5b6c21c877f5144391dfeb0ea8e"
