
require bijin-assets.inc

SRC_URI[md5sum] = "436fe2268831aa593c6c206a6bb8d00d"
SRC_URI[sha256sum] = "9027cccd54221cee22bada1bacdf6aaee699d6da2f7f8dd2e85c5094ce3bd0c4"
