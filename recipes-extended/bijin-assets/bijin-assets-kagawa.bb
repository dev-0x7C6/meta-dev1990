
require bijin-assets.inc

SRC_URI[md5sum] = "e72bca1b02758fc104f79153702c933c"
SRC_URI[sha256sum] = "21abaa81a7fe80ea524fefd481e9853cccaf9ede0935587b8d72289dba9cd498"
