
require bijin-assets.inc

SRC_URI[md5sum] = "ace333897a1c999df2765b246fe7b6c8"
SRC_URI[sha256sum] = "f6307b4519cca72c7c05e134243b74cd511eb96fc451f9e4d4234841e85e4c1f"
