
require bijin-assets.inc

SRC_URI[md5sum] = "18a1af2188d497d6ad8a59e13a9e3a2f"
SRC_URI[sha256sum] = "d0da07d489d177c6e4ecd5f0c5b4e706cbba8b49d4d38e4a2870e48039c9710c"
