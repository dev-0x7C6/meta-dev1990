
require bijin-assets.inc

SRC_URI[md5sum] = "76a4a02c115331f2c2505b664c99f134"
SRC_URI[sha256sum] = "c03f55b19e3b094b5ef9d791ac03b93dbc8917cad45dc469bf585733fef2d009"
