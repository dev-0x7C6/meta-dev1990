
require bijin-assets.inc

SRC_URI[md5sum] = "6797d9808cc6859119f7e2aa366bf1b1"
SRC_URI[sha256sum] = "5121efce41ebbb755b20813b90814f2fb1be016e2d587be333338a8c20d121a9"
