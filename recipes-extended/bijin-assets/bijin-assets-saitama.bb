
require bijin-assets.inc

SRC_URI[md5sum] = "14ced55d98e6489e6cb8f8661515e643"
SRC_URI[sha256sum] = "acc62ae098aa367e2908fd422c8cfa4643f009bf35b67f24340b1f35cd6db82e"
