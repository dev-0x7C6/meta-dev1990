
require bijin-assets.inc

SRC_URI[md5sum] = "0616561c923f61124ccc5c71c9f5d99e"
SRC_URI[sha256sum] = "d1b38589fc831d67388386496e67d71597ac7c65e4aae748834ec1c4da87377a"
