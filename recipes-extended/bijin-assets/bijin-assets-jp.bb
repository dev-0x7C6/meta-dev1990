
require bijin-assets.inc

SRC_URI[md5sum] = "4468fe4a8231f6bef1602391c94cbdba"
SRC_URI[sha256sum] = "57d06035481c28a5d7dc958d9fcb2927a16780dcaf49c51f16400c93b6e5abe2"
