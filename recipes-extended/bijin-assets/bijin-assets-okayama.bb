
require bijin-assets.inc

SRC_URI[md5sum] = "7a492e69cef1bdf33fdf56e7163a36c0"
SRC_URI[sha256sum] = "cb4e49b7887734d9b74a7b5aedbac14301ebcf4043330e5faa9ba7059e2f51e3"
