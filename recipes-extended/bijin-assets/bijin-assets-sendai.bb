
require bijin-assets.inc

SRC_URI[md5sum] = "3fc6620d187cab692c00c40857de7b1c"
SRC_URI[sha256sum] = "d7cd45af11acddb0f5a1250bf4292d7d6b4de4d1d66218e2495c5a3410e68dd4"
