
require bijin-assets.inc

SRC_URI[md5sum] = "65f0883878a0be36f7d83c5652708b1a"
SRC_URI[sha256sum] = "0bf2539bf8dc15617ba4c427a168c32fa1eaba70676f77d2c1adaa08db4627c8"
