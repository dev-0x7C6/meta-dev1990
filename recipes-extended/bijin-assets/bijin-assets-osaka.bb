
require bijin-assets.inc

SRC_URI[md5sum] = "a9a33d98d347eeafb7485aba66394482"
SRC_URI[sha256sum] = "b5a89d184afe44385ce9c69fc688be424090dbefed8f4f744a4d4efea136f886"
