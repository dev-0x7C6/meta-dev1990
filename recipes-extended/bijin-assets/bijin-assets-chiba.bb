
require bijin-assets.inc

SRC_URI[md5sum] = "d36bc344ade41be9096bbc65c7f57f13"
SRC_URI[sha256sum] = "aec38c8d2a1874747854730eb8ee69afac06f0cf8db66aa8188a2cce40d2d8f9"
