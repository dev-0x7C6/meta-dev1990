
require bijin-assets.inc

SRC_URI[md5sum] = "fabd3523f05d5754121caaacb2b0cb4c"
SRC_URI[sha256sum] = "d3640d663e39eabd73acd4ddc1c2032e1618e2bf4cd0d17740454a0af4a574fe"
