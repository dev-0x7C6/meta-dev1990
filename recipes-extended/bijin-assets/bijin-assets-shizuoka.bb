
require bijin-assets.inc

SRC_URI[md5sum] = "525e9a47e77253159a259e8edb1b4a83"
SRC_URI[sha256sum] = "3d57e10405f0ecb42ad25f44ef02465ee5eddbd6652ad37aa31d0e2ee5f5fa11"
