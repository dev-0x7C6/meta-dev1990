
require bijin-assets.inc

SRC_URI[md5sum] = "d1c5146acd49f7150feb680882980690"
SRC_URI[sha256sum] = "2bfcf20f576ec0a52e78803f4eb3a08602fe55b052b19915bde5e4a5db9e3602"
