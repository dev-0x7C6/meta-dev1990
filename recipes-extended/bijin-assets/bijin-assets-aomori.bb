
require bijin-assets.inc

SRC_URI[md5sum] = "1b1edfc5722708111f93d92f506ed9eb"
SRC_URI[sha256sum] = "2b54951b766df2964ff700869a8468dc81001a55189deb66c969e418d52a4e20"
