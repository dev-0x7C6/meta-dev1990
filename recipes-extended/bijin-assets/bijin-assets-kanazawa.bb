
require bijin-assets.inc

SRC_URI[md5sum] = "afb3a58f4b2348014832e3373b7570f6"
SRC_URI[sha256sum] = "9d9858665758aa2c06bdce9f0f9a898a9c7d9e5f504aaa2864dc675208efd3ac"
