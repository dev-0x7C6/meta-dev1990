
require bijin-assets.inc

SRC_URI[md5sum] = "6f6631db811bc74af610714cdca3a0e2"
SRC_URI[sha256sum] = "38d9c5005557d6b788f854fa5f6c0c233347162c0de2eb706c20f32ce2eb54c4"
